# Keil uVision project programmer.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: programmer
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\source\driver;..\source\malloc;..\source\system;..\source\usb\config;..\source\usb\lib;..\source\include;..\source\fatfs;..\source\text;..\source\app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group entry
    ../source/entry/: startup_stm32f10x_hd.s
  group driver
    ../source/driver/: flash.c spi.c sram.c timer.c led.c MMC_SD.C exti.c power_control.c
  group malloc
    ../source/malloc/: malloc.c
  group system
    ../source/system/: delay.c sys.c usart.c
  group usb_cfg
    ../source/usb/config/: hw_config.c mass_mal.c memory.c msd.c scsi_data.c stm32f10x_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group usb_core
    ../source/usb/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group main
    ../source/main/: main.c
  group fatfs
    ../source/fatfs/: diskio.c exfuns.c ff.c mycc936.c
    ../source/text/: fontupd.c
  group app
    ../source/app/: lower.c
